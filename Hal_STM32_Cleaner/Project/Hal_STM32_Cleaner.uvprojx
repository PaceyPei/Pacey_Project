# Keil uVision project Hal_STM32_Cleaner.uvprojx, settings and files
target Hal_STM32_Cleaner (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Hal_STM32_Cleaner +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ..\Driver\HAL\Inc;..\Driver\HAL\Drivers\STM32F1xx_HAL_Driver\Inc;..\Driver\HAL\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Driver\HAL\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Driver\HAL\Drivers\CMSIS\Include;..\Driver\BSP;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/APP
    ../Application/: comm.c comm.h
  group Application/BSP
    ../Driver/BSP/: bsp_usart.c bsp_usart.h bsp.c bsp.h
  group Application/HAL
    ../Driver/HAL/Src/: dma.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c usart.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Driver/HAL/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Driver/HAL/Drivers/CMSIS/Device/ST/STM32F1xx/Include/: system_stm32f1xx.h
software components: CMSIS:CORE 4.1.0
